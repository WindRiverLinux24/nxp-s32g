require linux-yocto-secure.inc
