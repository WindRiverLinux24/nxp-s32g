require linux-yocto-nxp-s32g.inc

KBRANCH:nxp-s32g  = "v5.15/standard/preempt-rt/nxp-sdk-5.15/nxp-s32g"


