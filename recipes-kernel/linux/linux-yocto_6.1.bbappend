require linux-yocto-nxp-s32g.inc

KBRANCH:nxp-s32g  = "v6.1/standard/nxp-sdk-5.15/nxp-s32g"

SRCREV_machine:kb-v6.1-standard-nxp-sdk-5.15-nxp-s32g = "c35789c18149bed4d149a893a16ba61f589a3d20"
SRCREV_meta_6.1:nxp-s32g = "8b555bd39017d9e6b19a0e2c98e563c5ebccef14"
